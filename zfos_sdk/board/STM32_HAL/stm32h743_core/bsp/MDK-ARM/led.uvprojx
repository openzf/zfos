# Keil uVision project led.uvprojx, settings and files
target led (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H743IITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.3.1
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x81FFFFF)                CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: led +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_BOARD_H743_CORE=1,USE_HAL_DRIVER,STM32H743xx
  c include: ../Core/Inc; ../Drivers/STM32H7xx_HAL_Driver/Inc; ../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32H7xx/Include; ../Drivers/CMSIS/Include; ..\..\..\zf_hal; ..\..\..\zf_hal\user_misc_drv; ..\..\..\..\..\board; ..\..\..\..\..\zfos; ..\..\..\..\..\zfos\components\drivers; ..\..\..\..\..\zfos\components\fs; ..\..\..\..\..\zfos\components\drivers\gpio; ..\..\..\..\..\zfos\components\drivers\i2c; ..\..\..\..\..\zfos\components\drivers\lcd; ..\..\..\..\..\zfos\components\drivers\spi; ..\..\..\..\..\base_app
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Application/MDK-ARM
    ./: startup_stm32h743xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma2d.c fmc.c i2c.c ltdc.c quadspi.c sdmmc.c spi.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c
  group bsp_driver
    ../../../zf_hal/zf_hal_drv/: zf_hal_drv_delay.c zf_hal_drv_gpio.c zf_hal_drv_i2c.c zf_hal_drv_lcd_8080.c zf_hal_drv_lcd_rgb.c zf_hal_drv_qspi.c zf_hal_drv_sdmmc.c zf_hal_drv_spi.c zf_hal_drv_uart.c
    ../../../zf_hal/: zf_hal_drv_manager.c
  group bsp_user_driver
    ../../../zf_hal/user_misc_drv/: user_driver_sd.c
  group board
    ../../: board.c
  group zfos/component/driver
    ../../../../../zfos/components/drivers/: zf_device.c zf_driver.c zf_driver_common.c zf_ramdisk.c zf_touch.c
    ../../../../../zfos/components/drivers/gpio/: key.c led.c
    ../../../../../zfos/components/drivers/i2c/: zf_si2c.c gt91x.c ft5206.c oled.c
    ../../../../../zfos/components/drivers/lcd/: lcd_config.c zf_lcd.c zf_lcd_8080.c
    ../../../../../zfos/components/drivers/spi/: qspi_flash.c spi_flash.c zf_sspi.c lcd_spi.c
  group zfos/filesystem/fatfs
    ../../../../../zfos/components/fs/: zf_fs.c
    ../../../../../zfos/components/fs/FATFS/src/: diskio.c fatfs.c ff.c ff_gen_drv.c
    ../../../../../zfos/components/fs/FATFS/src/option/: syscall.c ccsbcs.c
    ../../../../../zfos/components/fs/FATFS/user/: sd_diskio.c user_diskio.c user_qspiflash.c user_ramdisk.c
  group zfos
    ../../../../../zfos/: zfos.c
  group app
    ../../../../../base_app/app/: app.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_cortex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_dma2d.c stm32h7xx_ll_fmc.c stm32h7xx_hal_sdram.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_ltdc_ex.c stm32h7xx_hal_qspi.c stm32h7xx_ll_sdmmc.c stm32h7xx_ll_delayblock.c stm32h7xx_hal_sd.c stm32h7xx_hal_sd_ex.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
software components: CMSIS:CORE 4.3.0
